<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <file>
    <name>$PROJ_DIR$\..\base64.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\HttpAuth.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\HttpCore.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\HttpDebug.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\HttpDynamic.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\HttpSocket.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\HttpStatic.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\HttpString.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\sha1.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\strlib.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\example\common\webserver.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\WebSockHandler.c</name>
  </file>
</project>


